# IAR project CC2640App.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX; CONNECTABLE_BEACON_SUPPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $TI_BLE_SDK$\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; $TI_BLE_SDK$/Projects/ble/Include; $TI_BLE_SDK$/Projects/ble/ICall/Include; $TI_BLE_SDK$/Projects/ble/Profiles/Roles/CC26xx; $TI_BLE_SDK$/Projects/ble/Profiles/Roles; $TI_BLE_SDK$/Projects/ble/Profiles/DevInfo; ../../../../../Profiles/EddystoneURLCfg/CC26xx; ../../../../../Profiles/EddystoneURLCfg; $TI_BLE_SDK$/Projects/ble/common/cc26xx; $TI_BLE_SDK$/Projects/ble/common/cc26xx/time; $TI_BLE_SDK$/Components/applib/heap; $TI_BLE_SDK$/Components/ble/hci; $TI_BLE_SDK$/Components/ble/controller/CC26xx/include; $TI_BLE_SDK$/Components/ble/host; $TI_BLE_SDK$/Components/hal/target/CC2650/rom; $TI_BLE_SDK$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK$/Components/hal/include; $TI_BLE_SDK$/Components/osal/include; $TI_BLE_SDK$/Components/services/sdata; $TI_BLE_SDK$/Components/services/saddr; $TI_BLE_SDK$/Components/icall/include; $TI_BLE_SDK$/Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimpleEddystoneBeaconAppFlashROM.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SimpleEddystoneBeaconAppFlashROM.out
  ILINK.IlinkIcfFile: $TI_BLE_SDK$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROMDbg (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: SimpleEddystoneBeaconAppFlashROMDbg.hex
  ILINK.IlinkOutputFile: SimpleEddystoneBeaconAppFlashROMDbg.out
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
configuration FlashOnly_OAD_ImgB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ICALL; ICALL_STACK0_ADDR=0xF000; FEATURE_OAD_ONCHIP; IMAGE_INVALIDATE; HAL_IMAGE_B; POWER_SAVING; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX; CONNECTABLE_BEACON_SUPPORT
  ICCARM.IExtraOptions: -f $TI_BLE_SDK$\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; $TI_BLE_SDK$/Projects/ble/Include; $TI_BLE_SDK$/Projects/ble/ICall/Include; $TI_BLE_SDK$/Projects/ble/Profiles/Roles/CC26xx; $TI_BLE_SDK$/Projects/ble/Profiles/Roles; $TI_BLE_SDK$/Projects/ble/Profiles/DevInfo; ../../../../../Profiles/EddystoneURLCfg/CC26xx; ../../../../../Profiles/EddystoneURLCfg; $TI_BLE_SDK$/Projects/ble/Profiles/OAD/CC26xx; $TI_BLE_SDK$/Projects/ble/common/cc26xx; $TI_BLE_SDK$/Projects/ble/common/cc26xx/time; $TI_BLE_SDK$/Components/applib/heap; $TI_BLE_SDK$/Components/ble/hci; $TI_BLE_SDK$/Components/ble/controller/CC26xx/include; $TI_BLE_SDK$/Components/ble/host; $TI_BLE_SDK$/Components/hal/target/CC2650/rom; $TI_BLE_SDK$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK$/Components/hal/include; $TI_BLE_SDK$/Components/osal/include; $TI_BLE_SDK$/Components/services/sdata; $TI_BLE_SDK$/Components/services/saddr; $TI_BLE_SDK$/Components/icall/include; $TI_BLE_SDK$/Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  OBJCOPY.OOCOutputFile: SBP_OAD_ImgB.hex
  postbuild: python "C:\Python27\Scripts\hex2bin.py" -r "6000:EFFF" "FlashOnly_OAD_ImgB\Exe\SBP_OAD_ImgB.hex" "FlashOnly_OAD_ImgB\Exe\OADbin.bin"
  ILINK.IlinkOutputFile: SBP_OAD_ImgB_FlashOnly.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkIcfFile: $TI_BLE_SDK$\Projects\ble\common\cc26xx\IAR\cc26xx_ble_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
configuration FlashOnly_OAD_ST_ExtFlash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; FEATURE_OAD; FEATURE_OAD_BIM; HAL_IMAGE_E; xHEAPMGR_SIZE=2672; HEAPMGR_SIZE=3000; TI_DRIVERS_PIN_INCLUDED; TI_DRIVERS_I2C_INCLUDED; TI_DRIVERS_SPI_INCLUDED; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX; CONNECTABLE_BEACON_SUPPORT; FW_VERSION=1.10; SENSORTAG_HW
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; $TI_BLE_SDK$/Projects/ble/Include; $TI_BLE_SDK$/Projects/ble/ICall/Include; $TI_BLE_SDK$/Projects/ble/Profiles/Roles/CC26xx; $TI_BLE_SDK$/Projects/ble/Profiles/Roles; $TI_BLE_SDK$/Projects/ble/Profiles/DevInfo; ../../../../../Profiles/EddystoneURLCfg/CC26xx; ../../../../../Profiles/EddystoneURLCfg; $TI_BLE_SDK$/Projects/ble/Profiles/OAD/CC26xx; $TI_BLE_SDK$/Projects/ble/common/cc26xx; $TI_BLE_SDK$/Projects/ble/common/cc26xx/Time; $TI_BLE_SDK$/Components/applib/heap; $TI_BLE_SDK$/Components/ble/hci; $TI_BLE_SDK$/Components/ble/controller/CC26xx/include; $TI_BLE_SDK$/Components/ble/host; $TI_BLE_SDK$/Components/hal/target/CC2650/rom; $TI_BLE_SDK$/Components/hal/target/CC2650TIRTOS; $TI_BLE_SDK$/Components/hal/target/_common/cc26xx; $TI_BLE_SDK$/Components/hal/include; $TI_BLE_SDK$/Components/osal/include; $TI_BLE_SDK$/Components/services/sdata; $TI_BLE_SDK$/Components/services/saddr; $TI_BLE_SDK$/Components/icall/include; $TI_BLE_SDK$/Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_BLE_SDK$/Projects/ble/SensorTag/CC26xx/Source/Application/Board_patch/interfaces; $TI_BLE_SDK$/Projects/ble/SensorTag/CC26xx/Source/Application/Board_patch/devices; $TI_BLE_SDK$/Projects/ble/SensorTag/CC26xx/Source/Application/Board_patch/CC26XXST_0120
  OBJCOPY.OOCOutputFile: SimpleEddystoneBeacon_OADExtFlash.hex
  postbuild: python "C:\Python27\Scripts\hexmerge.py" -o "FlashOnly_OAD_ST_ExtFlash\Exe\OAD_FULL_IMAGE.hex" -r "1000:1CFFF" --overlap=error "FlashOnly_OAD_ST_ExtFlash\Exe\SimpleEddystoneBeacon_OADExtFlash.hex":1000:EFFF "..\..\Stack\CC2640\FlashROM\Exe\SimpleEddystoneBeaconStackFlashROM.hex":F000:1CFFF
  ILINK.IlinkOutputFile: SimpleEddystoneBeacon_OADExtFlash.out
  ILINK.IlinkConfigDefines: APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: as above
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  group Application
    $TI_BLE_SDK$/Projects/ble/common/cc26xx/: board_key.c board_key.h board_lcd.c board_lcd.h util.c util.h
    ../../../Source/Application/: simpleEddystoneBeacon.c simpleEddystoneBeacon.h
    $TI_BLE_SDK$/Projects/ble/common/cc26xx/Time/: UTC_clock.c UTC_clock.h
  group Board/Devices
    $TI_BLE_SDK$/Projects/ble/SensorTag/CC26xx/Source/Application/Board_patch/Devices/: ext_flash.c ext_flash.h
  group Board/Interfaces
    $TI_BLE_SDK$/Projects/ble/SensorTag/CC26xx/Source/Application/Board_patch/Interfaces/: bsp_spi.c bsp_spi.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $TI_BLE_SDK$/Components/applib/heap/: heapmgr.h
    $TI_BLE_SDK$/Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    $TI_BLE_SDK$/Components/icall/include/: ICall.h
    $TI_BLE_SDK$/Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    $TI_BLE_SDK$/Projects/ble/ICall/Application/: bleUserConfig.c ICallBleAPI.c
    $TI_BLE_SDK$/Projects/ble/ICall/Include/: bleUserConfig.h ICallBleAPIMSG.h
  group Include
    $TI_BLE_SDK$/Components/ble/include/: gap.h gatt.h hci.h
    $TI_BLE_SDK$/Projects/ble/Profiles/Roles/: gapbondmgr.h
    $TI_BLE_SDK$/Projects/ble/Include/: gapgattserver.h
    $TI_BLE_SDK$/Components/osal/include/: osal_snv.h
  group PROFILES
    $TI_BLE_SDK$/Projects/ble/Profiles/DevInfo/CC26xx/: devinfoservice.c
    $TI_BLE_SDK$/Projects/ble/Profiles/DevInfo/: devinfoservice.h
    ../../../../../Profiles/EddystoneURLCfg/CC26xx/: eddystoneURLCfg.c
    ../../../../../Profiles/EddystoneURLCfg/: eddystoneURLCfg.h
    $TI_BLE_SDK$/Projects/ble/Profiles/OAD/CC26xx/: ext_flash_layout.h oad.c oad.h oad_target_externalFlash.c oad_target_internalFlash.c oadResetService.c
    $TI_BLE_SDK$/Projects/ble/Include/: gatt_profile_uuid.h
    $TI_BLE_SDK$/Components/ble/host/: gatt_uuid.c
    $TI_BLE_SDK$/Components/ble/include/: gatt_uuid.h
    $TI_BLE_SDK$/Projects/ble/Profiles/GATT/: gattservapp_util.c
    ../../../../../Profiles/Roles/CC26xx/: peripheral.c
    $TI_BLE_SDK$/Projects/ble/Profiles/Roles/CC26xx/: peripheral.h
    $TI_BLE_SDK$/Projects/ble/Profiles/Keys/CC26xx/: simplekeys.c
    $TI_BLE_SDK$/Projects/ble/Profiles/Keys/: simplekeys.h
  group Startup
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SRF06EB/: Board.c
    $TI_BLE_SDK$/Projects/ble/SensorTag/CC26xx/Source/Application/Board_patch/: Board.c
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg IAR-Boundary.bdef IAR-Boundary.xcl
    $TI_BLE_SDK$/Projects/ble/common/cc26xx/IAR/: cc26xx_ble_app.icf cc26xx_ble_app_oad.icf
